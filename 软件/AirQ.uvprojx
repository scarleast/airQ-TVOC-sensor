# Keil uVision project AirQ.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AirQ +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,_RTE_
  c include: .\USER;.\Config;.\HARDWARE;.\HARDWARE\OLED;.\SYSTEM\sys;.\SYSTEM\delay;.\SYSTEM;.\SYSTEM\IIC;.\HARDWARE\CCS811
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./USER/: main.c init.c led.c
  group Config
    ./Config/: Port.c
  group Hardware
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/CCS811/: CCS811.c
    ./HARDWARE/ccs811/: CCS811_IIC.c CCS811.h
  group System
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
software components: CMSIS:CORE 5.2.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
